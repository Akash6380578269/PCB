# Repository Akash6380578269/PCB

## KiCad design buck.kicad_pcb

Board: 2 copper layers, 25.5 x 27.5 mm, 8 parts (0 on the bottom side), 6 nets.

Parts:
C1: C; C_Radial_D6.3mm_H5.0mm_P2.50mm
C2: C; C_Radial_D6.3mm_H11.0mm_P2.50mm
J1, J2: IN; Samtec_HPM-02-01-x-S_Straight_1x02_Pitch5.08mm
L2: SPM3015T-4R7M-LR; L_Axial_L11.0mm_D4.5mm_P15.24mm_Horizontal_Fastron_MECC
R1, R2: R_US; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
U1: TPS561208DDCR; D_5W_P10.16mm_Horizontal

Connections:
/IN: C1.1, J1.1
/VBST: C2.1, U1.2 (SW)
GND: C1.2, J1.2, J2.1, R2.2, U1.1 (GND)
unnamed: C2.2, L2.1
unnamed: J2.2, L2.2, R1.1
unnamed: R1.2, R2.1
